# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD1602.c LCD1602.h DS18B20.c DS18B20.h OneWire.c OneWire.h AT24C02.c AT24C02.h Delay.c Delay.h I2C.c I2C.h Key.c Key.h Timer.c Timer.h
